# IAR project Project.ewp, settings and files
configuration STM32F4xx-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE; USE_STM32F4XX_NUCLEO; ENABLE_SPI_FIX; NO_PRINTF
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\Src\X_NUCLEO_IKS01A1; ..\Src\ov7725; ..\Src\iNEMO_AHRS; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB04A1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB04A1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h
  group Example/EWARM
    ./: startup_stm32f411xe.s
  group Example/User
    ../Src/: bluenrg_interface.c bluenrg_sdk_api.c clock.c com.c com.h control.c control.h LSM9DS0_AHRS.c LSM9DS0_AHRS.h main.c my_fun.h Nemo_M1_AHRS_Lib_v121.lib NRF24L0.c NRF24L0.h outputdata.c outputdata.h serial_protocol.c serial_protocol.h stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Example/User/AHRS
    ../Src/X_NUCLEO_IKS01A1/: hts221.c
    ../Src/iNEMO_AHRS/: iNEMO_AHRS.c iNEMO_AHRS.h iNEMO_AHRS_MemMan_1.c iNEMO_EKF.c iNEMO_EKF.h iNEMO_math.c iNEMO_math.h
  group Example/User/MEMS
    ../Src/X_NUCLEO_IKS01A1/: hts221.h hum_temp.h imu_6axes.h lis3mdl.c lis3mdl.h lps25h.c lps25h.h lps25hb.c lps25hb.h lsm6ds0.c lsm6ds0.h lsm6ds3.c lsm6ds3.h magneto.h pressure.h x_nucleo_iks01a1.c x_nucleo_iks01a1.h x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_hum_temp.h x_nucleo_iks01a1_imu_6axes.c x_nucleo_iks01a1_imu_6axes.h x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_magneto.h x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_pressure.h
  group Example/User/ov7725
    ../Src/ov7725/: ov7725.c ov7725.h sccb.c sccb.h
  group MIddlewares/STM32_BlueNRG/HCI/controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group MIddlewares/STM32_BlueNRG/HCI/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group MIddlewares/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c list.c osal.c
