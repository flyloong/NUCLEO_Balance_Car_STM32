<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM32F4xx-Nucleo</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Doc</name>
    <file>
      <name>$PROJ_DIR$\..\readme.txt</name>
    </file>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>BSP</name>
      <group>
        <name>STM32F4xx-Nucleo</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo\stm32f4xx_nucleo.c</name>
        </file>
      </group>
      <group>
        <name>X-NUCLEO-IDB04A1</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB04A1\stm32_bluenrg_ble.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Src\system_stm32f4xx.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\stm32f4xx_hal_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_i2c_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\stm32f4xx_hal_i2c_ex.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_uart.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Example</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\startup_stm32f411xe.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <group>
        <name>AHRS</name>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\hts221.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\iNEMO_AHRS\iNEMO_AHRS.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\iNEMO_AHRS\iNEMO_AHRS.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\iNEMO_AHRS\iNEMO_AHRS_MemMan_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\iNEMO_AHRS\iNEMO_EKF.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\iNEMO_AHRS\iNEMO_EKF.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\iNEMO_AHRS\iNEMO_math.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\iNEMO_AHRS\iNEMO_math.h</name>
        </file>
      </group>
      <group>
        <name>MEMS</name>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\hts221.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\hum_temp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\imu_6axes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\lis3mdl.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\lis3mdl.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\lps25h.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\lps25h.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\lps25hb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\lps25hb.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\lsm6ds0.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\lsm6ds0.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\lsm6ds3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\lsm6ds3.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\magneto.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\pressure.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\x_nucleo_iks01a1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\x_nucleo_iks01a1.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_hum_temp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_hum_temp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_imu_6axes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_imu_6axes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_magneto.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_magneto.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_pressure.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_pressure.h</name>
        </file>
      </group>
      <group>
        <name>ov7725</name>
        <file>
          <name>$PROJ_DIR$\..\Src\ov7725\ov7725.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\ov7725\ov7725.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\ov7725\sccb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\ov7725\sccb.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Src\bluenrg_interface.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\bluenrg_sdk_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\clock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\com.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\com.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\control.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\control.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\LSM9DS0_AHRS.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\LSM9DS0_AHRS.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\my_fun.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\Nemo_M1_AHRS_Lib_v121.lib</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\NRF24L0.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\NRF24L0.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\outputdata.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\outputdata.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\serial_protocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\serial_protocol.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_it.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>MIddlewares</name>
    <group>
      <name>STM32_BlueNRG</name>
      <group>
        <name>HCI</name>
        <group>
          <name>controller</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\hci\controller\bluenrg_gap_aci.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\hci\controller\bluenrg_gatt_aci.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\hci\controller\bluenrg_hal_aci.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\hci\controller\bluenrg_l2cap_aci.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\hci\hci.c</name>
          </file>
        </group>
        <group>
          <name>Interface</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface\bluenrg_itf_template.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>Utils</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\utils\gp_timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\utils\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\utils\osal.c</name>
      </file>
    </group>
  </group>
</project>


